Commit message: updates

File: urdf/support.urdf (robot description, URDF)
Before this commit: robot support, 2 links, 1 joints
Links:
- link support: geometry collision mesh filename=support_concave.obj; visual mesh filename=support.obj
